{attribute 'strict'}
TYPE E_RRCS_State :
(
	IDLE,
	CHECK_GATEWAY, 
	CHECK_ALIVE, 
	CHECK_CONN_ARTIST, 
	GET_PORTS, 
	GET_SOURCES, 
	SET_SOURCE,
	WAIT,
	ERROR)BYTE; 
END_TYPE
